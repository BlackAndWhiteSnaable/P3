<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\2017_10_23_testingSTM32.ewp</path>
    </project>
    <batchBuild />
</workspace>
